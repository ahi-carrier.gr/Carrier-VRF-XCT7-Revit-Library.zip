Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2021-03-17T12:43:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 17 12:43:39 2021 * Host: DS-SGH416PJB5 * Database: C:\Users\DARSHAND\AppData\Local\Temp\{57A6DCFA-1F71-4209-BFEF-0F62F67D4B0E}\ifc * Database version: 5507 * Database creation date: Wed Mar 17 12:43:38 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Mar 17 12:43:39 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 17 12:43:39 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcBuildingElementProxy: 40VU005C-7S-QEE, IDU-Compact 4-way cassette:40VU005C-7S-QEE:258888
In: Level 1
Type - Classification: 40VU005C-7S-QEE (Uniformat); Material: Colour- RGB -255 255 255, Colour RGB-000 000 255
Pset_BuildingElementProxyCommon - Reference: 40VU005C-7S-QEE; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: Carrier
