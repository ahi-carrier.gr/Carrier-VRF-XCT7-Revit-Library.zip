Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2021-03-17T12:39:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 17 12:39:23 2021 * Host: DS-SGH416PJB5 * Database: C:\Users\DARSHAND\AppData\Local\Temp\{0F4D7E55-6D9C-4C77-ABC1-0ABE430C62C1}\ifc * Database version: 5507 * Database creation date: Wed Mar 17 12:39:21 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Mar 17 12:39:22 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 17 12:39:22 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcBuildingElementProxy: 40VC009F-7S-QEE, IDU-Flex Ceiling Floor DC_1000:40VC009F-7S-QEE:258044
In: Level 1
Type - Material: Colour RGB-255 255 255, Colour RGB-000 000 255
Pset_ManufacturerTypeInformation - Manufacturer: Carrier
Pset_BuildingElementProxyCommon - Reference: 40VC009F-7S-QEE; IsExternal: no
