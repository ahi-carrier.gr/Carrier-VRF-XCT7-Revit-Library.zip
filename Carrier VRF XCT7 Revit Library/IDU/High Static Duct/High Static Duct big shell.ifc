Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2021-03-17T13:01:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 17 13:01:37 2021 * Host: DS-SGH416PJB5 * Database: C:\Users\DARSHAND\AppData\Local\Temp\{5F1DF2CC-6F98-43F8-8FAA-FC2B807FA581}\ifc * Database version: 5507 * Database creation date: Wed Mar 17 13:01:35 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Mar 17 13:01:36 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 17 13:01:36 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcBuildingElementProxy: 40VD036H-7S-QEE, High Static Duct big shell:40VD036H-7S-QEE:258674
In: Level 1
Type - Material: colour RGB-255 255 255, Colour RGB - 255 000 000
Pset_ManufacturerTypeInformation - Manufacturer: Carrier
Pset_BuildingElementProxyCommon - Reference: 40VD036H-7S-QEE; IsExternal: no
