Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2021-03-30T14:44:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 30 14:44:27 2021 * Host: DS-SGH416PJB5 * Database: C:\Users\DARSHAND\AppData\Local\Temp\{7BE82639-CCAD-490F-ACE9-4CFE46ACABA9}\ifc * Database version: 5507 * Database creation date: Tue Mar 30 14:44:23 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Mar 30 14:44:24 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 30 14:44:24 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcBuildingElementProxy: 40VK005S-7S-QEE, High wall_855_208_280:40VK005S-7S-QEE:257762
In: Level 1
Type - Material: Colour - RGB 255 255 255, Colour - RGB 000 000 255
Pset_ManufacturerTypeInformation - Manufacturer: Carrier
Pset_BuildingElementProxyCommon - Reference: 40VK005S-7S-QEE; IsExternal: no
