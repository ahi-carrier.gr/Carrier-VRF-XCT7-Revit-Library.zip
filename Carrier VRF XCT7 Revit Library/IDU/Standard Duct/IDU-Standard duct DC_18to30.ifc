Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2021-03-17T12:26:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 17 12:26:03 2021 * Host: DS-SGH416PJB5 * Database: C:\Users\DARSHAND\AppData\Local\Temp\{0A8651E7-7C36-4A6F-98DB-74951E271717}\ifc * Database version: 5507 * Database creation date: Wed Mar 17 12:26:01 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Mar 17 12:26:02 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 17 12:26:02 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcBuildingElementProxy: 40VD018S-7S-QEE, IDU-Standard duct DC_middle:40VD018S-7S-QEE:257838
In: Level 1
Type - Material: colour RGB-255 255 255, Colour RGB - 255 000 000
Pset_ManufacturerTypeInformation - Manufacturer: Carrier
Pset_BuildingElementProxyCommon - Reference: 40VD018S-7S-QEE; IsExternal: no
